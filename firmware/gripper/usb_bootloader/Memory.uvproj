# Keil uVision project Memory.uvproj, settings and files
target MCB2378 Board (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory +hex
  AfterMake: cmd /c copy .\obj\Memory.hex .
  c flags: Optim=4
  c define: USB_PRODUCT_ID=0x0410
  c misc: -c99
  c include: ..\firmware\src;..\firmware\src\USB;.\src;.\src\sbl
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ../firmware/src/: Startup.s SWI.s
  group Source Code
    ./src/: main.c memory.c
    ../firmware/src/: Serial.c clk.c leds.c timer.c
  group SBL
    ./src/sbl/: DiskImg.c mscuser.c sbl_iap.c
  group USB
    ../firmware/src/USB/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
