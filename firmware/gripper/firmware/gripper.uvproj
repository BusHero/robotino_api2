# Keil uVision project gripper.uvproj, settings and files
target MCB2140 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: gripper
  c flags: Optim=3
  c define: NPRINTF_DEBUG USB_PRODUCT_ID=0x040F
  c misc: --c99
  c include: .\src;..\..\tlv_common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    src/: Startup.s
  group Source Code
    src/: main.c
    ./src/: leds.c Retarget.c Serial.c timer.c clk.c util.c SWI.s parser.c producer.c version.c pwm.c adc.c
    ../../tlv_common/: com.c tlv_parser.c tlv_producer.c
  group USB
    ./src/USB/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
