# Keil uVision project firmware.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: firmware +hex
  c flags: Optim=4
  c include: \src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000000 size 0xe
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group src
    ./src/: main.c robotinoserial.c adc.c motor.c pwm.c fpga.c udp.c spi.c fpga_config.c io.c com.c display_led.c vel_new2old.c vel_old2new.c power.c eeprom.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib
    ./src/: LPC23_EMAC.c Net_Config.c Telnet_uif.c LPC2300.s
  group Debug
    ./src/: Retarget.c Serial.c
