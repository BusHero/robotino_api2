# Keil uVision project charger.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: charger +hex
  c define: STM32F10X_LD USE_STDPERIPH_DRIVER
  c include: .\CMSIS\CM3;.\stmpl\inc;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Startup
    ./src/: startup_stm32f10x_ld.s
  group stmpl
    ./stmpl/src/: stm32f10x_wwdg.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./CMSIS/CM3/: core_cm3.c system_stm32f10x.c
  group Source
    ./src/: stm32_it.c timer.c io.c main.c Retarget.c serial.c can.c adc.c spi.c dac.c
