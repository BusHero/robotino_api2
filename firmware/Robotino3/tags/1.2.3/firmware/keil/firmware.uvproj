# Keil uVision project firmware.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: firmware +hex
  AfterMake: fromelf --bin .\obj\firmware.axf -o .\firmware.bin
  AfterMake: cmd /c copy /Y .\obj\firmware.hex .
  c flags: Optim=4
  c define: NCOMSERIAL NMCB2300 NPRINTF_DEBUG MPU6050
  c include: ..\src;..\src\eMPL;..\..\..\..\tlv_common
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x7e000
  memory RVCT6: RAM 0x80000000 size 0xe
  memory RVCT9: RAM 0x40001000 size 0x7000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group src
    ../src/: main.c io.c Retarget.c timer.c producer.c parser.c fpga.c fpga_config.c comserial.c comusb.c Serial.c adc.c util.c motor.c pwm.c odometry.c udp.c charger.c CAN.c i2c.c clk.c gyro.c spi.c ssp.c power.c version.c charger_isp.c chargerfw.c watchdog.c MPU6000.c
    ../../../../tlv_common/: com.c tlv_producer.c tlv_parser.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_ARM_L.lib
    ../src/: Net_Config.c LPC23_EMAC.c
  group usb
    ../src/: usbuser.c cdcuser.c usbcore.c usbdesc.c usbhw.c SWI.s
  group Startup Code
    ../src/: LPC2300.s
  group eMPL
    ../src/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
