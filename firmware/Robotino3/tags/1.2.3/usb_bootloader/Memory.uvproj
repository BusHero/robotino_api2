# Keil uVision project Memory.uvproj, settings and files
target MCB2378 Board (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Memory +hex
  AfterMake: cmd /c copy .\obj\Memory.hex .
  c flags: Optim=4
  c include: ..\..\..\bootloader_common\src;.\src
  memory RVCT4: ROM 0x0 size 0x1fff
  memory RVCT9: RAM 0x40000000 size 0xfff
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup Code
    ../../../bootloader_common/src/: LPC2300.s
  group Disk Image
    ../../../bootloader_common/src/: DiskImg.c
  group Source Code
    ./src/: usbcfg.h memory.c main.c
    ../../../bootloader_common/src/: usbhw.c usbcore.c usbdesc.c usbuser.c mscuser.c sbl_iap.c Serial.c timer.c
    ../firmware/src/: power.c
