# Keil uVision project firmware.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: firmware +hex
  AfterMake: fromelf --bin .\obj\firmware.axf -o .\firmware.bin
  AfterMake: cmd /c copy /Y .\obj\firmware.hex .
  c flags: Optim=4
  c include: .\src;..\..\..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0x7e000
  memory RVCT6: RAM 0x80000000 size 0xe
  memory RVCT9: RAM 0x40000100 size 0xff00
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group src
    ./src/: main.c io.c Serial.c Retarget.c timer.c com.c vema.c
  group usb
    ./src/: usbuser.c cdcuser.c usbcore.c usbdesc.c usbhw.c SWI.s
  group Startup Code
    ./src/: LPC2300.s
  group can
    ./src/: CAN.c
  group adc
    ./src/: adc.c
